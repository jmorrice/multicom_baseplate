# IAR project Backup (3) of BP_Control.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1763 NXP LPC1763
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BP_Control.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: T:\PROJEKTE\AFC\Automatisierung\Matratze\Base Plate\BasePlate V0.x Control\BasePlate Control BL V0.5 FW V0.1\BP Control\config\LPC1768_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    lib/: arm_comm.h bildverarbeitung.c bildverarbeitung.h bootloader.c bootloader.h cam.c cam.h default.c default.h flash.c flash.h fsm.c fsm.h i2c.h i2c_master.c i2c_master.h i2c_slave.c i2c_slave.h incl.h iolpc1766.h main.c nvic.c nvic.h pwm.c pwm.h sm5822.c sm5822.h user_code.c user_code.h
    src/: cstartup_M.s
